require optee-examples.inc
COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
SRCREV = "9a7dc598591990349d88b4dba3a37aadd6851295"

